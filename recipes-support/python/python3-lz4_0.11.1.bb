inherit setuptools3
require python-lz4.inc

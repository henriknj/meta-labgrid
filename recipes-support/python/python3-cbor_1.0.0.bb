inherit setuptools3
require python-cbor.inc

inherit setuptools3
require python-snappy.inc

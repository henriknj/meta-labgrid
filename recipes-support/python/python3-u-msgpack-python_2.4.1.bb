inherit setuptools3
require python-u-msgpack-python.inc

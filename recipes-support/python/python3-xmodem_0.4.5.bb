inherit setuptools3
require python-xmodem.inc

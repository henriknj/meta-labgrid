inherit setuptools3
require python-py-ubjson.inc

inherit setuptools3
require python-graphviz.inc
